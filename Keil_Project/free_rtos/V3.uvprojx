# Keil uVision project V3.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c rtos_driver.c rtos_driver.h tm4c123gh6pm.h SysTick_driver.h SysTick_driver.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
